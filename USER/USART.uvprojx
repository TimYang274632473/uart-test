# Keil uVision project USART.uvprojx, settings and files
target USART (6110000::V6.11::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\APP\SYSTICK;..\APP\CAN;..\APP\USART;..\SYSTEM\sys;..\APP\CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_can.c
  group APP
    ../APP/SYSTICK/: systick.c
    ../APP/CAN/: can.c
    ../APP/USART/: usart.c
    ../APP/CONFIG/: config.h
  group ILLUSTRATE
    ../ILLUSTRATE/: illustrate.txt
